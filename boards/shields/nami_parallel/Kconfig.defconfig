## boards/shields/nami_parallel/Kconfig.defconfig
```kconfig
if SHIELD_NAMI_PARALLEL

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Nami Parallel"

endif
```
